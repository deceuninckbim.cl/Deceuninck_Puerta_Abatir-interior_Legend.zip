Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-22T10:26:14
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 22 10:26:14 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\4ce67168-e4ba-47bd-b539-a9c34c494968\cb62b39b-af31-44b4-b744-f5ffd343395f\ifc * Database version: 5507 * Database creation date: Fri Dec 22 10:26:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 22 10:26:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 22 10:26:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Puerta_Abatir-interior_Legend:Deceuninck_Puerta_Abatir-interior_Legend, Deceuninck_Puerta_Abatir-interior_Legend:Deceuninck_Puerta_Abatir-interior_Legend:562771
In: Level 1
Type - Classification: B2030100 Glazed Doors & Entrances (Uniformat); Material: Aluminum, Galvanized steel, PVC, Deceuninck - 1.White/PVC, Glass
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Function: Interior; Wall Closure: By host
Type - Dimensions - Construction Height: 2305 mm; Construction Width: 905 mm; Glass Height: 2052 mm; Glass Width: 652 mm; Height: 2300 mm; Max. Height: 2300 mm; Max. Width: 1000 mm; Rough Height: 2232 mm; Sash Fit: 35 mm; Width: 900 mm
Type - Identity Data - Assembly Code: B2030100; Assembly Description: Glazed Doors & Entrances; Constructive depth: 76 mm; C-Section Model: https://skfb.ly/oOGK7; Glass Type: Thermopanel; Glazing capacity: 4 a 36mm; Internacional Certification: ISO 9001-ISO 14001-BS OHSAS 18001 approved by TUV Rheiland; Line: Legend; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: Casement door; NOTE*: Consider corner joint profile 11644; OmniClass Number: 23.30.10.00; OmniClass Title: Doors; Opening: Interior; Panels: 1 casement; Technical Area Chile: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 77; Type Name: Deceuninck_Puerta_Abatir-interior_Legend; URL: www.deceuninck.cl; Use: Interior
Type - Materials and Finishes - Available colours: https://deceuninckbim.cl/pdf/fichas/legend-abatir-marco.pdf; Frame: Deceuninck - 1.White/PVC; Handle: PVC; Rail: Aluminum; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.White/PVC
Type - Model Properties - Acoustic insulation: Rw=32 (-1;-5) dB according to ISO 140-3, ISO 717 **; Air permeability: Class 4 according to EN 12207; Fire Retardant: Class C-s3, d2 according to EN 13501-1; Water tightness: Class E750 according to EN 12208; Wind load resistance: Class C2/B3 according to EN 12210
Type - Other - Category: Doors; Family Name: Deceuninck_Puerta_Abatir-interior_Legend
Type - Structural - Includes reinforcement: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deceuninck
Type - Pset_ProductRequirements - Category: Doors
Type - Pset_ProvisionForVoid - Width: 900 mm; Height: 2300 mm
Material: Glass, Deceuninck - 1.White/PVC
Pset_BuildingElementProxyCommon - Reference: Deceuninck_Puerta_Abatir-interior_Legend; sets with these values: 2
Constraints - Level: Level: Level 1; Sill Height: 0 mm
Dimensions - Area: 5.12461 m2; Volume: 0.0604133 m3
Identity Data - Mark: 54
Other - Family: Deceuninck_Puerta_Abatir-interior_Legend: Deceuninck_Puerta_Abatir-interior_Legend; Family and Type: Deceuninck_Puerta_Abatir-interior_Legend: Deceuninck_Puerta_Abatir-interior_Legend; Head Height: 2300 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Puerta_Abatir-interior_Legend: Deceuninck_Puerta_Abatir-interior_Legend; Type Id: Deceuninck_Puerta_Abatir-interior_Legend: Deceuninck_Puerta_Abatir-interior_Legend
Phasing - Phase Created: New Construction
